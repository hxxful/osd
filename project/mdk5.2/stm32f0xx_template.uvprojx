# Keil uVision project stm32f0xx_template.uvprojx, settings and files
target demo (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F031K6 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x1000) IROM(0x08000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: stm32f0xx_template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F0XX_HD
  c include: ..\..\user;..\..\libs;..\..\system;..\..\drivers;..\..\drivers\common;..\..\bsp;..\..\bsp\STM32F0xx_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group user
    ../../user/: main.c app_speedgroup.c app_led.c app_max7456.c app_debug.c
  group libs
    ../../libs/: lib_kalman.c lib_math.c
  group system
    ../../system/: sys.c sys_api.c sys_clock.c sys_delay.c sys_printf.c sys_protocol.c
  group drivers
    ../../drivers/common/: drv_common.c drv_clock.c drv_systick.c drv_timers.c drv_spi_hardware.c drv_usart_hardware.c
    ../../drivers/: drv_max7456.c drv_led.c
  group bsp
    ../../bsp/startup/arm/: startup_stm32f031.s
  group doc
    ../../: 问题总结.txt
